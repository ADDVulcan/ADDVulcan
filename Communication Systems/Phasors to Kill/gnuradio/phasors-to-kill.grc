options:
  parameters:
    generate_options: no_gui
    id: top
    output_language: python
    run_options: run
    title: Phasors to Kill
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: out.dat
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: bypassed}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/jboone/Downloads/Hack-A-Sat 2020/Phasors to Kill/phasor2-victor25864romeo/challenge.wav
    nchan: '2'
    repeat: 'False'
  states: {}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '4'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    log: 'True'
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '4'
    timing_bw: 6.28/100.0
    verbose: 'True'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}

connections:
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', digital_psk_demod_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [digital_psk_demod_0, '0', blocks_char_to_float_0, '0']
- [digital_psk_demod_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
