options:
  parameters:
    author: mike
    generate_options: qt_gui
    id: phasor
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    sensitivity: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: channel2.cfile
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '4'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: challenge.wav
    nchan: '2'
    repeat: 'False'
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_file_sink_0, '0']
- [blocks_repeat_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_wavfile_source_0, '0', blocks_null_sink_0, '0']
- [blocks_wavfile_source_0, '1', blocks_repeat_0, '0']

metadata:
  file_format: 1
